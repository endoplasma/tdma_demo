# Keil uVision project contiki.uvproj, settings and files
target STM32F407 Flash (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: contiki
  c flags: Optim=1
  c define: __STM32F407__ __USE_LCD __STM_EVAL UIP_CONF_IPV6=1 UIP_CONF_IPV6_RPL=1 AUTOSTART_ENABLE
  c include: ..\..\cpu\stm32f407;..\..\platform\stm3240g-eval;..\..\cpu\avr\radio\rf230bb;..\..\core;..\..\core\dev;..\..\core\lib;..\..\core\net;..\..\core\net\mac;..\..\core\net\rime;..\..\core\net\rpl;..\..\core\sys;..\..\core\cfs;..\..\core\ctk;..\..\core\loader;..\..\cpu\stm32f407\VCP;..\..\cpu\stm32f407\STM32_USB_OTG_Driver\inc;..\..\cpu\stm32f407\STM32_USB_Device_Library\Class\cdc\inc;..\..\cpu\stm32f407\STM32_USB_Device_Library\Core\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group project
    ./: udpPlug.c led_timer_blink.c
  group platform
    ../../platform/stm3240g-eval/: adc-sensor.c battery-sensor.c button-sensor.c contiki-main.c GLCD_16bitIF_STM32F4xx.c leds_arch.c
  group cpu
    ../../cpu/stm32f407/: system_stm32f4xx.c startup_stm32f4xx.s rtimer-arch.c clock.c watchdog.c nvic.c uart4.c uart4-putchar.c random.c unique_id.c
  group cpu-usb
    ../../cpu/stm32f407/VCP/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c vcp_putchar.c
    ../../cpu/stm32f407/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../../cpu/stm32f407/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../cpu/stm32f407/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group radio-rf230bb
    ../../cpu/avr/radio/rf230bb/: halbb.c rf230bb.c
  group rime
    ../../core/net/rime/: rimeaddr.c timesynch.c rimestats.c
  group mac
    ../../core/net/mac/: cxmac.c xmac.c nullmac.c lpp.c frame802154.c sicslowmac.c nullrdc.c nullrdc-noframer.c mac.c framer-nullmac.c framer-802154.c csma.c contikimac.c phase.c
  group system
    ../../core/sys/: process.c autostart.c profile.c timetable.c timetable-aggregate.c compower.c
    ../../core/loader/: elfloader.c
  group threads
    ../../core/sys/: mt.c
  group libs
    ../../core/lib/: memb.c mmem.c list.c print-stats.c ifft.c crc16.c checkpoint.c ringbuf.c sensors.c
    ../../core/sys/: timer.c etimer.c ctimer.c energest.c rtimer.c stimer.c
  group dev
    ../../core/dev/: serial-line.c leds.c nullradio.c
  group net
    ../../core/net/: netstack.c uip-debug.c packetbuf.c queuebuf.c packetqueue.c
  group uip
    ../../core/net/: uip6.c tcpip.c psock.c uip-udp-packet.c uip-split.c resolv.c tcpdump.c uiplib.c simple-udp.c uip-icmp6.c uip-nd6.c uip-packetqueue.c sicslowpan.c neighbor-attr.c neighbor-info.c uip-ds6.c
  group rpl
    ../../core/net/rpl/: rpl.c rpl-dag.c rpl-icmp6.c rpl-timers.c rpl-of-etx.c rpl-ext-header.c
  group apps
    ../../apps/ping6/: ping6.c
